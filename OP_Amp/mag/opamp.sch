v {xschem version=3.4.6RC file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {pmoscs.sym} -210 -100 0 0 {name=x1}
C {pmosamp.sym} 250 70 0 1 {name=x2}
C {nmosamp.sym} -210 80 0 0 {name=x3}
C {nmoscs.sym} 250 -100 0 1 {name=x4}
C {devices/lab_pin.sym} -60 -130 2 0 {name=p1 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} -60 -110 2 0 {name=p2 sig_type=std_logic lab=net1}
C {devices/lab_pin.sym} -60 -90 2 0 {name=p3 sig_type=std_logic lab=net2}
C {devices/lab_pin.sym} -60 -70 2 0 {name=p4 sig_type=std_logic lab=net3}
C {devices/lab_pin.sym} -60 60 2 0 {name=p5 sig_type=std_logic lab=net4}
C {devices/lab_pin.sym} -60 80 2 0 {name=p6 sig_type=std_logic lab=OUT}
C {devices/lab_pin.sym} -60 100 2 0 {name=p7 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 100 -130 0 0 {name=p8 sig_type=std_logic lab=net2}
C {devices/lab_pin.sym} 100 -110 0 0 {name=p9 sig_type=std_logic lab=net3}
C {devices/lab_pin.sym} 100 -90 0 0 {name=p10 sig_type=std_logic lab=RS}
C {devices/lab_pin.sym} 100 -70 0 0 {name=p11 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 100 40 0 0 {name=p12 sig_type=std_logic lab=net1}
C {devices/lab_pin.sym} 100 60 0 0 {name=p13 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 100 80 0 0 {name=p14 sig_type=std_logic lab=OUT}
C {devices/lab_pin.sym} 100 100 0 0 {name=p15 sig_type=std_logic lab=net4}
C {devices/lab_pin.sym} 400 40 2 0 {name=p16 sig_type=std_logic lab=VIP}
C {devices/lab_pin.sym} 400 60 2 0 {name=p17 sig_type=std_logic lab=VIN}
C {devices/iopin.sym} -390 -140 2 0 {name=p18 lab=VDD}
C {devices/iopin.sym} -390 -120 2 0 {name=p19 lab=GND}
C {devices/iopin.sym} -390 -100 2 0 {name=p20 lab=RS}
C {devices/iopin.sym} -390 -80 2 0 {name=p21 lab=OUT}
C {devices/ipin.sym} -390 -60 0 0 {name=p22 lab=VIP}
C {devices/ipin.sym} -390 -40 0 0 {name=p23 lab=VIN}
